# Keil uVision project demo.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: .\User;.\RTE;.\Hardware;.\Library
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c main.h ai_detect.c ai_detect.h anomaly_log.c game.c anomaly_log.h font.h stm32f10x_conf.h
  group Hardware
    ./Hardware/: led.c led.h aht20.c aht20.h bmp280.c bmp280.h key.c key.h lcd.c lcd.h my_i2c.c my_i2c.h stm32f10x_conf.h bh1750.c bh1750.h sd.c sd.h tm1637.c tm1637.h sr04.c sr04.h usart1.c usart1.h esp8266.c esp8266.h touch.c touch.h
  group Library
    ./Library/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_armv81mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm3.h core_cm4.h core_cm7.h core_cm23.h core_cm33.h core_cm35p.h core_cm55.h core_cm85.h core_sc000.h core_sc300.h core_starmc1.h misc.h mpu_armv7.h mpu_armv8.h pac_armv81.h pmu_armv8.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_conf.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h tz_context.h
  group RTE
    ./RTE/Device/STM32F103C8/: RTE_Device.h misc.h stm32f10x_conf.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h
    ./RTE/_Target_1/: RTE_Components.h
software components: CMSIS:CORE 5.6.0, Device:GPIO 1.3, Device:Startup 1.0.0
